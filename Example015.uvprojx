# Keil uVision project Example015.uvprojx, settings and files
target Source (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Example015
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Example015;..\..\FreeRTOS-Source\include;..\..\FreeRTOS-Source\portable\RVDS\ARM_CM3;..\..\FreeRTOS-Source\demo_code;..\..\..\..\LCD project\tivaware c -series
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group FreeRTOS_source
    ../../FreeRTOS-Source/: list.c queue.c tasks.c
    ../../FreeRTOS-Source/portable/MemMang/: heap_1.c
    ../../FreeRTOS-Source/portable/RVDS/ARM_CM3/: port.c
  group Demo_source
    ../../FreeRTOS-Source/demo_code/: basic_io.c
    ./: tm4c123gh6pm.h bitwise_operation.h lcd_drivers.c lcd_drivers.h main.c UART.c UART.h
    ../../../../LCD project/tivaware c -series/driverlib/rvmdk/: driverlib.lib
  group System_source
    ./: startup_MPS_CM3.s
  group New Group
    ../../../../../../Fall_20-21/Micro/tivaware c -series/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.4.0
